options:
  parameters:
    generate_options: qt_gui
    id: bpsk_rx_usrp_a_jetsonRTL
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: chan_rate
  id: variable
  parameters:
    value: samp_rate/decim
  states: {}
- name: decim
  id: variable
  parameters:
    value: '20'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: freq_rf
  id: variable
  parameters:
    value: 923e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '20'
    step: '1'
    stop: '55'
    value: '20'
  states: {}
- name: n_taps_rx
  id: variable
  parameters:
    value: 11*int(sps_rx) + 1
  states: {}
- name: rrc_delay
  id: variable
  parameters:
    value: (n_taps_rx - 1)//2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps_rx
  id: variable
  parameters:
    value: chan_rate/sym_rate
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: 25e3
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: rrc_delay
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: str(Path.home() / 'sdr-alertas' / 'datos' / 'bpsk_rx_rf_USRP_tx.u8')
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: digital.constellation_bpsk().base()
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.03'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.02'
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps_rx
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 20e3, 10e3)
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'tabs_rx@0: 0,1,1,1'
    name: Antes de Costas - salida RRC
    size: '1024'
    type: complex
    update_time: '0.2'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'tabs_rx@1: 0,0,1,1'
    name: Despues de Costas - todas las muestras
    size: '1024'
    type: complex
    update_time: '0.2'
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'tabs_rx@1: 0,1,1,1'
    name: Simbolos recuperados
    size: '1024'
    type: complex
    update_time: '0.2'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: chan_rate
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: 'tabs_rx@0: 1,0,1,2'
    label1: Antes RRC
    label2: Despues RRC
    name: Espectro antes y despues del RRC
    nconnections: '2'
    type: complex
    update_time: '0.2'
    wintype: window.WIN_HANN
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'tabs_rx@0: 0,0,1,1'
    label1: I antes RRC
    label2: Q antes RRC
    label3: I despues RRC
    label4: Q despues RRC
    name: I-Q antes y despues del RRC
    nconnections: '2'
    size: '600'
    srate: chan_rate
    type: complex
    update_time: '0.2'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'tabs_rx@1: 1,0,1,2'
    label1: I recuperada
    label2: Q residual
    name: I-Q despues de Costas
    size: '400'
    srate: chan_rate
    type: complex
    update_time: '0.2'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'tabs_rx@2: 0,0,1,2'
    label1: Bits RX
    name: Bits recuperados
    size: '100'
    srate: sym_rate
    type: float
    update_time: '0.2'
    ymax: '1.2'
    ymin: '-0.2'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '1'
    ntaps: 11*int(sps_rx) + 1
    samp_rate: chan_rate
    sym_rate: sym_rate
    type: fir_filter_ccf
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl=0
    bb_gain0: '20'
    freq0: freq_rf
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: tabs_rx
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,1
    label0: Canal y filtrado
    label1: Sincronizacion
    label2: Bits recuperados
    num_tabs: '3'
  states: {}
- name: import_rutas
  id: import
  parameters:
    imports: from pathlib import Path
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_delay_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_agc_xx_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_2, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_file_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_uchar_to_float_0, '0']
- [digital_costas_loop_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_1, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [root_raised_cosine_filter_0, '0', digital_costas_loop_cc_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_const_sink_x_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_freq_sink_x_0_0, '1']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0, '1']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
