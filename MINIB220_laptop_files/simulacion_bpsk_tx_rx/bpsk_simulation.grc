options:
  parameters:
    generate_options: no_gui
    id: tx_usrp
    output_language: python
    run_options: run
    title: simulation_bpsk
  states: {}

blocks:
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: str(Path.home() / 'sdr-alertas' / 'datos' / 'bpsk_rx.u8')
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: str(Path.home() / 'sdr-alertas' / 'datos' / 'bpsk_tx.u8')
    repeat: 'False'
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1+0j, 1+0j]'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: digital.constellation_bpsk().base()
  states: {}
- name: import_rutas
  id: import
  parameters:
    imports: from pathlib import Path
  states: {}

connections:
- [blocks_file_source_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
