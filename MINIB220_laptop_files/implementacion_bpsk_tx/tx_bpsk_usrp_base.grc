options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: tx_bpsk_usrp
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: amplitude
  id: variable_qtgui_range
  parameters:
    start: '0.4'
    step: '0.01'
    stop: '0.6'
    value: '0.4'
  states: {}
- name: freq_rf
  id: variable
  parameters:
    value: 923e6
  states: {}
- name: freq_tono
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '50'
    step: '1'
    stop: '65'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '40'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: samp_rate / sps
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: str(Path.home() / 'sdr-alertas' / 'datos' / 'bpsk_tx.u8')
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amplitude
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2*math.pi*freq_tono/samp_rate
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1+0j, 1+0j]'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq_rf
    fftsize: '8192'
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    gain: sps
    interp: sps
    ntaps: 11*sps + 1
    samp_rate: samp_rate
    sym_rate: sym_rate
    type: interp_fir_filter_ccf
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq_rf
    clock_source0: internal
    gain0: gain
    len_tag_name: ''
    samp_rate: samp_rate
    stream_chans: '[0]'
    sync: none
    type: fc32
  states: {}
- name: import_rutas
  id: import
  parameters:
    imports: from pathlib import Path
  states: {}

connections:
- [blocks_file_source_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_rotator_cc_0, '0']
- [blocks_rotator_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_rotator_cc_0, '0', uhd_usrp_sink_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
